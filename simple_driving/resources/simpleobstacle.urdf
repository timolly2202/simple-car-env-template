Commit message: More obstacle stuff

File: simple_driving/resources/simpleobstacle.urdf (robot description, URDF)
Before this commit: robot simpleobstacle, 1 links, 0 joints
Links:
- link base_link: geometry collision cylinder length=0.5 radius=0.25; visual cylinder length=1 radius=0.5
